<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sam4l_sam-ba_flash.ewp</path>
	</project>
</workspace>
