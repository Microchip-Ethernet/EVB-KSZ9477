<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>common</name>
    <group>
      <name>services</name>
      <group>
        <name>clock</name>
        <group>
          <name>sam4l</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\common\services\clock\sam4l\dfll.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\common\services\clock\sam4l\osc.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\common\services\clock\sam4l\pll.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\common\services\clock\sam4l\sysclk.c</name>
          </file>
        </group>
      </group>
      <group>
        <name>sleepmgr</name>
        <group>
          <name>sam4l</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\common\services\sleepmgr\sam4l\sleepmgr.c</name>
          </file>
        </group>
      </group>
      <group>
        <name>usb</name>
        <group>
          <name>class</name>
          <group>
            <name>cdc</name>
            <group>
              <name>device</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\..\common\services\usb\class\cdc\device\udi_cdc.c</name>
              </file>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\..\common\services\usb\class\cdc\device\udi_cdc_desc.c</name>
              </file>
            </group>
          </group>
        </group>
        <group>
          <name>udc</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\common\services\usb\udc\udc.c</name>
          </file>
        </group>
      </group>
    </group>
    <group>
      <name>utils</name>
      <group>
        <name>interrupt</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\..\common\utils\interrupt\interrupt_sam_nvic.c</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>sam</name>
    <group>
      <name>applications</name>
      <group>
        <name>sam4l_sam-ba</name>
        <file>
          <name>$PROJ_DIR$\..\..\main.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\sam_ba_monitor.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\usart_sam_ba.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>boards</name>
      <group>
        <name>sam4l_ek</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\boards\sam4l_ek\init.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>drivers</name>
      <group>
        <name>bpm</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\drivers\bpm\bpm.c</name>
        </file>
      </group>
      <group>
        <name>flashcalw</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\drivers\flashcalw\flashcalw.c</name>
        </file>
      </group>
      <group>
        <name>gpio</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\drivers\gpio\gpio.c</name>
        </file>
      </group>
      <group>
        <name>usbc</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\drivers\usbc\usbc_device.c</name>
        </file>
      </group>
    </group>
    <group>
      <name>utils</name>
      <group>
        <name>cmsis</name>
        <group>
          <name>sam4l</name>
          <group>
            <name>source</name>
            <group>
              <name>templates</name>
              <group>
                <name>iar</name>
                <file>
                  <name>$PROJ_DIR$\..\..\..\..\utils\cmsis\sam4l\source\templates\iar\startup_sam4l.c</name>
                </file>
              </group>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\utils\cmsis\sam4l\source\templates\exceptions.c</name>
              </file>
            </group>
          </group>
        </group>
      </group>
    </group>
  </group>
</project>


